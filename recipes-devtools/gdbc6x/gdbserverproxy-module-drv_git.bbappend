PR_append = ".tisdk0"

require gdbc6x-1.1.0.inc
