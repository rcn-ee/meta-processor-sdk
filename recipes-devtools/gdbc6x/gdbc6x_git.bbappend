require gdbc6x-keystone.inc

PR_append = ".tisdk0"
