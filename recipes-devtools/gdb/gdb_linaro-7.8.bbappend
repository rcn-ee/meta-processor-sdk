PR_append = ".tisdk0"

PACKAGECONFIG[python] = "--with-python=${WORKDIR}/python,--without-python,python,python-modules"
