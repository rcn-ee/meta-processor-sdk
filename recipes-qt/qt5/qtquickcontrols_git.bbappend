PR_append = ".tisdk0"
include qt5-path-hack.inc
