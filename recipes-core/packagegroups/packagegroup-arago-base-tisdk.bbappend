PR:append = ".psdk0"

RDEPENDS:${PN}:append = "iperf3"

