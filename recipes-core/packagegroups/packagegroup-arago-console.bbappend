PR:append = ".psdk0"

ARAGO_FSTOOLS:append = " \
    e2fsprogs-resize2fs \
"
