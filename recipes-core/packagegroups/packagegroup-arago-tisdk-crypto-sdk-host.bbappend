PR_append = ".tisdk0"

CRYPTO_RDEPENDS_append_keystone = " cryptodev-module-src \
                                    ti-crypto-examples-src \
"
