PR_append = ".tisdk2"

TIDL_PKGS = "tidl-examples-dev tidl-viewer tidl-utils tidl-import"

EXTRA_PKGS_append_dra7xx = " ${TIDL_PKGS}"
