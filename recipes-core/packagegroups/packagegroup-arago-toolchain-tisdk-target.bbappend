PR_append = ".tisdk0"

TISDK_TOOLCHAIN_BASE_TARGET_keystone += "\
    packagegroup-arago-tisdk-multimedia-sdk-target \
"
