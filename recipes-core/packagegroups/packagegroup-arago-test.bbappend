PR_append = ".tisdk0"

ARAGO_TEST_append_ti33x = " mstpd"
ARAGO_TEST_append_ti43x = " mstpd"
ARAGO_TEST_append_omap-a15 = " mstpd"
