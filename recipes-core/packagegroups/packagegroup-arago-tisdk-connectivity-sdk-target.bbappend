PR_append = ".tisdk0"

CONNECTIVITY_RDEPENDS_append_ti33x = " \
    wpantund-dev \
"
CONNECTIVITY_RDEPENDS_append_ti43x = " \
    wpantund-dev \
"
