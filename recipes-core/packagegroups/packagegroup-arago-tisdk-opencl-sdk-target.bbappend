PR_append = ".tisdk0"

UTILS_append = " python-pyopencl-dev"
