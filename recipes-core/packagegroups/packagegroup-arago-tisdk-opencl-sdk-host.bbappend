PR_append = ".tisdk1"

UTILS_append_dra7xx = "tidl-examples-src"
