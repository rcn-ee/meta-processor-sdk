PR_append = ".tisdk0"

S_keystone = "${WORKDIR}/git/cryptos_apps_program"

RDEPENDS_${PN}_append_keystone = " ti-crypto-examples"
