PR_append = ".tisdk0"

SRCREV = "42384fa5a36a0a046e8d1ef566d2cc4be84c7fdb"

RDEPENDS_${PN} += "posix-smp-demo"
