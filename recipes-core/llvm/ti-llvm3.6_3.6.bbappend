PR_append = ".tisdk0"

LLVM_GIT_SRCREV = "8ff2a35c586a3d3f624712e0943777613a017bc5"
CLANG_GIT_SRCREV = "1bffed84d31aa9271ef4c91301f833d103e94010"
