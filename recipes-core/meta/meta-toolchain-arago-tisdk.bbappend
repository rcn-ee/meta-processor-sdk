PR_append = ".tisdk0"

TOOLCHAIN_CLEANUP_PACKAGES_append = " \
    ti-llvm3.3 \
    ti-llvm3.3-dev \
"
