PR_append = ".tisdk0"

IMAGE_INSTALL += "\
    packagegroup-arago-tisdk-connectivity \
"
