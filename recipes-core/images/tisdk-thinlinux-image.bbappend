PR_append = ".tisdk1"

WIC_CREATE_EXTRA_ARGS += " --no-fstab-update"

IMAGE_INSTALL_append += " resize-rootfs"
