PR:append = ".psdk0"

WIC_CREATE_EXTRA_ARGS:append = " --no-fstab-update"
