LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=78c2cc91e172ca96d6f8e4a76c739ec6"

SRC_URI[md5sum] = "d6b1a2cb5e194ae43f849c125b71c8db"
SRC_URI[sha256sum] = "eef610b23933c54d5d921c92578ae5f89813438fded840c2e9809d378dc765d3"

PYPI_PACKAGE = "websockets"
PV = "10.4"
inherit pypi setuptools3
