PR_append = "-tisdk0"

EXTRA_LDFLAGS ?= ""
