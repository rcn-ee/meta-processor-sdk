PR_append = ".tisdk0"

COMPATIBLE_MACHINE = "(omap3|ti33x|ti43x|omap-a15|keystone)"

VIDEO_FILES_keystone = "video_720p "
