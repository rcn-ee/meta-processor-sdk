PACKAGECONFIG_append = " \
                   tracer-hooks \
"

PR_append = ".tisdk0"
