PR_append = ".tisdk0"

COMPATIBLE_MACHINE = "dra7xx|keystone"

SRCREV = "e4ea007d0ddeb95ae01742293454ef3c87a6e84c"

DEPENDS = "gstreamer1.0 gstreamer1.0-plugins-base hevc-arm-decoder"
