PR_append = ".int1"

DEPENDS_append = " pulseaudio bison-native"
