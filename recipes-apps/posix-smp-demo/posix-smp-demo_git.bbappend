require recipes-apps/posix-smp-demo/posix-smp-demo-01.01.00.00.inc
