PR_append = ".tisdk0"

INSANE_SKIPT_${PN} += "file-rdeps"
