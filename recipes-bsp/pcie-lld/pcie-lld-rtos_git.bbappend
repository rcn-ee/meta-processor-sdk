# Below commit ID corresponds to "DEV.PCIE_LLD.02.02.00.12"
PCIE_LLD_SRCREV = "90c85b801cc8524deb57d897d204597b11fa26c4"

PV = "02.02.00.12"
PR = "r0"
