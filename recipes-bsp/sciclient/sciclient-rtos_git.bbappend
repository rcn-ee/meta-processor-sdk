PR_append = ".tisdk0"

LIMSOCS_am65xx-hs-evm = "am65xx"
LIMBOARDS_am65xx-hs-evm = "am65xx_evm"
BOARD_PACKAGE_am65xx-hs-evm = "am65xx_evm"
