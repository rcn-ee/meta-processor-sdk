# Below commit ID corresponds to "DEV.MCASP_LLD.01.01.00.08A"
MCASP_LLD_SRCREV = "56fc546fe3f0ba89477dfa020bcc4b6aa8ce64f3"

PV = "01.01.00.08A"
PR = "r0"
