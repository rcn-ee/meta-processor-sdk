PKTLIB_SRCREV = "2aa4843d79c344c2d76d0d5d32ecda3d7213d514"

PV = "2.1.0.6"
PR_append = ".tisdk0"
