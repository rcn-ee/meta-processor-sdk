# Below commit ID corresponds to "DEV.UART_LLD.01.00.00.09"
UART_LLD_SRCREV = "f3670e497186b5ec5258d0e51fb1ebdaa3d60577"

PV = "01.00.00.09"
PR = "r0"
