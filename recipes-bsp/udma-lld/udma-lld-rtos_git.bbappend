# Below commit ID corresponds to "DEV.UDMA_LLD.01.00.00.01A"
UDMA_LLD_SRCREV = "e03304e15bb7f1a86c77f1a9984361c822ab2b70"

PV = "01.00.00.01A"
PR = "r0"
