require hyplnk-lld-02.01.00.05.inc

PR_append = ".tisdk0"
