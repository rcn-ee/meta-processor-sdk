PR_append = ".tisdk1"

KERNEL_MODULE_AUTOLOAD += "uio_module_drv"
