# Below commit ID corresponds to "DEV.GPIO_LLD.01.00.00.09"
GPIO_LLD_SRCREV = "99a20a668f36217705d57f7cc2f7faf1a5533bbe"

PV = "01.00.00.09"
PR = "r0"
