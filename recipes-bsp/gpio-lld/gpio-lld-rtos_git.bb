inherit ti-pdk
require gpio-lld.inc
