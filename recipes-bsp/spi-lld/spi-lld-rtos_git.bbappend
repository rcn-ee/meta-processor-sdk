
# Below commit ID corresponds to "DEV.SPI_LLD.01.00.00.13A"
SPI_LLD_SRCREV = "2c6c4fe250383c8854be8fd58a6b599dbbe3fe8e"

PV = "01.00.00.13A"
PR = "r0"
