inherit ti-pdk
require spi-lld.inc

DEPENDS += "osal-rtos"
