PR_append = ".tisdk0"

SRC_URI = "git://git.ti.com/processor-sdk/processor-sdk-firmware.git;protocol=git;branch=master"
SRCREV = "a71b143562ab3d38bacb43a1f8d595876abe4e86"
