# Below commit ID corresponds to "DEV.USB_LLD.01.00.00.13"
USB_LLD_SRCREV = "bac7156bac2b11c964f67a79752e1d6178fb1e86"

PV = "01.00.00.13"
PR = "r0"
