PR_append = ".tisdk0"

require edma3-lld-02.12.01.23.inc

PLATFORMLIST_append = " tci6636k2h-evm \
                        tci66ak2g02-evm \
"
