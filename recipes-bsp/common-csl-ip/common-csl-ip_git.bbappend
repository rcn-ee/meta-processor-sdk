require common-csl-ip-3.3.0.inc
PR_append = ".tisdk0"

COMPATIBLE_MACHINE = "keystone|dra7xx|ti33x|ti43x"
