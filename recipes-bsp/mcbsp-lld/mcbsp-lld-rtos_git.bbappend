# Below commit ID corresponds to "DEV.MCBSP_LLD.01.00.00.09"
MCBSP_LLD_SRCREV = "e782f251a7009c786a208a15e6bc0331bb6808f6"

PV = "01.00.00.09"
PR = "r0"

