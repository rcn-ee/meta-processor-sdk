# Below commit ID corresponds to "DEV.MMCSD_LLD.01.00.00.10"
MMCSD_LLD_SRCREV = "9bb118bdc1ac46863f57a68d70f421734a4dcf25"

PV = "01.00.00.10"
PR = "r0"
