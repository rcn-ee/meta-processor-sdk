PV = "01.01.01.08A"

# Below commit ID corresponds to DEV.TFWK-01.01.01.08A
TRACEFRAMEWORK_SRCREV = "aeefaa1b932742a7eebaac034c64f74b03d795bf"
