PR_append = ".tisdk0"

LIC_FILES_CHKSUM = "file://Texas_Instruments_ipumm_Manifest.pdf;md5=5cc572579f07af266ab57fc17d762c7f"

SRCREV = "1bc0e3dcdda54d1575676e557c3b6c3f3d16261b"
