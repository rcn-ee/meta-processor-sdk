require recipes-bsp/osal/osal-01.00.00.10.inc
