inherit ti-pdk
require osal.inc
