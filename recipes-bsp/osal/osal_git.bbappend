require osal-1.0.0.inc
