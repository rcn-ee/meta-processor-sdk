require recipes-bsp/osal/osal-1.0.0.9.inc

COMPATIBLE_MACHINE_append = "|c66x"
