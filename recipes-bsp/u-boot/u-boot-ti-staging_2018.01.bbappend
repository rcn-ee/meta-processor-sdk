require u-boot-processor-sdk.inc

SPL_BINARY_am65xx-hs-evm = "tispl.bin_HS"
SPL_BINARYNAME_am65xx-hs-evm = "tispl.bin"

UBOOT_BINARY_am65xx-hs-evm = "u-boot.img_HS"
