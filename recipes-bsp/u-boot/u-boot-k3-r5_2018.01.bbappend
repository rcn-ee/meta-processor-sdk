require u-boot-processor-sdk.inc

UBOOT_MACHINE_am65xx-hs-evm = "am65x_hs_evm_r5_defconfig"
