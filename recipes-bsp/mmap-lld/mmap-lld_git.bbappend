require mmap-lld-02.00.00.06.inc

PR_append = ".tisdk0"
