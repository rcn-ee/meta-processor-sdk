PR_append = ".tisdk0"

require mmap-lld-02.00.00.07.inc

DEVICELIST_k2l-evm = "k2l"
DEVICELIST_k2g-evm = "k2g"
