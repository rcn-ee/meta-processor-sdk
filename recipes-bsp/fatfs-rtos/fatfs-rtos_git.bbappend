# Below commit ID corresponds to "DEV.FATFS_LLD.01.00.00.09"
FATFS_SRCREV = "a5652991a9dd9a9b9b9c5c2cf35d1417f8272b00"

PV = "01.00.00.09"
PR = "r0"
