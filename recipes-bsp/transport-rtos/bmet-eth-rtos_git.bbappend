require recipes-bsp/transport-rtos/ndk-path.inc
require recipes-bsp/transport-rtos/transport-01.00.00.11.inc

LIC_FILES_CHKSUM = "file://bmet_transport.h;beginline=12;endline=40;md5=6d209c698b273aef180b0c1d38469e8e"
