require pa-lld-03.00.01.07.inc

PR_append = ".tisdk0"
