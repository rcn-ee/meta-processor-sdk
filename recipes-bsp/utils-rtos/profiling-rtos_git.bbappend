# Below commit ID corresponds to "DEV.UTILS.01.00.00.05"
PROFILING_SRCREV = "a9ceef7bb6b75b590e1a13573179c7d8dfb9049c"

PV = "01.00.00.05"
PR = "r0"
