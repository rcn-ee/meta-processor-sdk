inherit ti-pdk
require pruss-lld.inc

DEPENDS += "osal-rtos"
