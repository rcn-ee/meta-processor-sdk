PR_append = ".tisdk0"

SRCREV = "00241c45f810c8b8e4f5ac66c3323fec8e43b621"

PV = "4.10.02.04+git${SRCPV}"
