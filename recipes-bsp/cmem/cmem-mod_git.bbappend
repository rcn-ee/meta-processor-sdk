require cmem-4.12.0.0.inc
