# Below commit ID corresponds to "DEV.PM_LLD.01.04.00.04"
PM_LLD_SRCREV = "1c0cae9b001137f68f34bf9168d7c3fa9036b1a6"

# Below commit ID corresponds to "DEV.PM_LLD.01.08.00.17"
PM_LLD_SRCREV_dra7xx-evm = "720f7df19f1b34cd72d8d3937baf5ff0011fd5dd"
PM_LLD_SRCREV_am57xx-evm = "720f7df19f1b34cd72d8d3937baf5ff0011fd5dd"

PV = "01.04.00.04"
PR = "r0"
