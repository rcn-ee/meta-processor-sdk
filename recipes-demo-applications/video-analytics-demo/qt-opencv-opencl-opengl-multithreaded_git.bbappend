PR_append = ".tisdk0"

CXXFLAGS_append = " -DOCV_NATIVE "
