PR_append = ".tisdk0"

POSIX_SMP_GIT_BRANCH = "master"
POSIX_SMP_SRCREV     = "ed013f29b8651d7fbc4aaf14a23c80880ee6a565"
