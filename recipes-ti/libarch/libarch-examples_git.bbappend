COMPATIBLE_MACHINE_append = "|dra7xx"

TARGET_dra7xx = "SOC_AM572x"
