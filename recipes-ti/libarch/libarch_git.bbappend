COMPATIBLE_MACHINE_append = "|dra7xx"
