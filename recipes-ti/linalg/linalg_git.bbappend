require linalg-next.inc
