PR_append = ".tisdk0"

require netapi-01.01.00.07.inc
