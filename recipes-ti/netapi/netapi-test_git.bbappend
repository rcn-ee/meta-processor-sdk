require netapi-01.01.00.08.inc
