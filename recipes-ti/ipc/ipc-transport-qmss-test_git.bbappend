PR_append = ".tisdk0"

PACKAGE_ARCH = "${MACHINE_ARCH}"

DEVICELIST_k2hk-evm = "k2h k2k"
DEVICELIST_k2e-evm = "k2e"
DEVICELIST_k2l-evm = "k2l"
