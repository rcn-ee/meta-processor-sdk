PR_append = ".tisdk1"

require ti-ipc-3.47.02.00.inc

require ti-ipc-rtos-3.47.02.00.inc
