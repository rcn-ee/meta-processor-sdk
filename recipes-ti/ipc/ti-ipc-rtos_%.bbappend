PR_append = ".ti-int0"

CREATE_SRCIPK = "1"
SRCIPK_INSTALL_DIR = "ipc_${PV}"
