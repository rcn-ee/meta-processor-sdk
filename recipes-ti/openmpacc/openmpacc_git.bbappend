PR_append = ".tisdk0"

require openmpacc-1.3.1.1.inc
