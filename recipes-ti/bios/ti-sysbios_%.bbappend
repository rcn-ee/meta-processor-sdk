LICENSE = "BSD & FatFS & Newlib"