PR_append = ".tisdk1"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0002-navigation-move-base-mmwave-changes.patch;patchdir=.."
