PR_append = ".tisdk0"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-navigation-rotate-recovery-mmwave-changes.patch;patchdir=.."
