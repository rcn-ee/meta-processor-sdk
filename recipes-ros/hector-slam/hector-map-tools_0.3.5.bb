DESCRIPTION = "hector_map_tools contains some functions related to accessing information from OccupancyGridMap maps."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=17;endline=17;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "nav-msgs libeigen"

require recipes-ros/hector-slam/hector-slam.inc
