PR_append = ".tisdk0"

RDEPENDS_${PN} += "\
    hector-map-tools \
    hector-nav-msgs \
    hector-trajectory-server \
"
