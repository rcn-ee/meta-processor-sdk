PR_append = "-tisdk0"

BBCLASSEXTEND += " nativesdk"
