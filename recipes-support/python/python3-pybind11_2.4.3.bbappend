PR_append = ".tisdk0"
BBCLASSEXTEND="native nativesdk"
