PR_append = ".tisdk0"

# SoC Performance Monitoring Utility

SRC_URI += " \
	file://0001-Add-soc-performance-monitor-utilites.patch \
"
