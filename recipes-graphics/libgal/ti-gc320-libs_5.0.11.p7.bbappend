PR_append = ".tisdk0"

FILES_${PN} += "${libdir}/*"
