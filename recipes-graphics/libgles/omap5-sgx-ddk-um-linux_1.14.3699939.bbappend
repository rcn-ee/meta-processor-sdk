PR_append = ".tisdk1"

SRCREV = "e91d6d37c28ae63c350fff9c91705fd315491093"

FILES_${PN}-plugins += " ${libdir}/libPVRScopeServices.so"
