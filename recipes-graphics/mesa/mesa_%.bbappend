PACKAGECONFIG_append = "gallium"
PACKAGECONFIG_append =" gallium-egl  "
PACKAGECONFIG_append =" gallium-gbm  "

PR_append = ".tisdk0"
